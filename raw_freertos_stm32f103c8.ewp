# IAR project raw_freertos_stm32f103c8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS; FreeRTOS; FreeRTOS\include; FreeRTOS\src; FreeRTOS\port; CMSIS\include; CMSIS\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: raw_freertos_stm32f103c8.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp
  group CMSIS/include
    CMSIS/include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm3.h stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
  group CMSIS/src
    CMSIS/src/: startup_stm32f103xb.s system_stm32f1xx.c
  group FreeRTOS
    FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/include
    FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/port
    FreeRTOS/port/: port.c portasm.s portmacro.h
  group FreeRTOS/src
    FreeRTOS/src/: heap_2.c list.c queue.c tasks.c
