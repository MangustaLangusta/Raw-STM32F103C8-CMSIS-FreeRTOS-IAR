<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\raw_freertos_stm32f103c8.ewp</path>
    </project>
    <batchBuild />
</workspace>
